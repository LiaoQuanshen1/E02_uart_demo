# Keil uVision project mm32f327x_g8p.uvprojx, settings and files
target mm32f327x_g8p_project (6240000::V6.24::ARMCLANG)
  device: MM32F3273G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.1.8
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F327X_G8P
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\user\inc;..\code;..\libraries;..\libraries\zf_common;..\libraries\zf_device;..\libraries\zf_driver;..\libraries\sdk;..\libraries\sdk\CMSIS\Include;..\libraries\sdk\drivers;..\libraries\components\fatfs\source;..\libraries\components\MENU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\libraries\sdk\mdk\linker\mm32f3277g_flash.scf
  group user_c
    ../USER/src/: main.c
    ../user/src/: isr.c
  group user_h
    ../user/inc/: isr.h
  group code
    ../code/: my_image_show.c my_image_show.h my_motor.c my_motor.h
  group zf_commen
    ../libraries/zf_common/: zf_common_clock.c zf_common_debug.c zf_common_fifo.c zf_common_font.c zf_common_function.c zf_common_interrupt.c
  group zf_driver
    ../libraries/zf_driver/: zf_driver_adc.c zf_driver_dac.c zf_driver_delay.c zf_driver_dma.c zf_driver_encoder.c zf_driver_exti.c zf_driver_flash.c zf_driver_gpio.c zf_driver_iic.c zf_driver_pit.c zf_driver_pwm.c zf_driver_sdio.c zf_driver_soft_iic.c zf_driver_soft_spi.c zf_driver_spi.c zf_driver_timer.c zf_driver_uart.c
  group sdk
    ../libraries/sdk/: system_mm32f3277g.c
    ../libraries/sdk/mdk/: startup_mm32f3277g.s
  group zf_device
    ../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_bluetooth_ch9141.c zf_device_camera.c zf_device_dl1a.c zf_device_dm1xa.c zf_device_gps_tau1201.c zf_device_icm20602.c zf_device_imu660ra.c zf_device_imu963ra.c zf_device_ips114.c zf_device_ips200.c zf_device_key.c zf_device_mpu6050.c zf_device_mt9v03x.c zf_device_oled.c zf_device_ov7725.c zf_device_scc8660.c zf_device_sdcard.c zf_device_tft180.c zf_device_tsl1401.c zf_device_type.c zf_device_virtual_oscilloscope.c zf_device_wifi_uart.c zf_device_wireless_uart.c zf_device_config.lib
  group components
    ../libraries/components/MENU/: zf_components_menu.c
    ../libraries/components/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
